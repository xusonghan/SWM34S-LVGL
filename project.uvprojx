# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.1.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1
  c define: RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __RTTHREAD__
  c include: packages\LVGL-v8.3.11\src\extra\libs\png;rt-thread\components\drivers\include;lvgl_app;rt-thread\components\drivers\include;build\libraries\SWM341_CSL\SWM341_StdPeriph_Driver;packages\LVGL-v8.3.11\src\extra\others\snapshot;packages\LVGL-v8.3.11\src\extra\widgets\tileview;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\others;packages\LVGL-v8.3.11\src\extra\libs\bmp;rt-thread\components\drivers\smp_call;packages\LVGL-v8.3.11\src\extra\others\fragment;packages\LVGL-v8.3.11\src\extra\others\msg;packages\LVGL-v8.3.11\src\draw\renesas;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;.;packages\LVGL-v8.3.11\src\draw\arm2d;packages\LVGL-v8.3.11\src\extra\layouts\flex;packages\LVGL-v8.3.11\src\extra\widgets\chart;build\libraries\SWM341_drivers;packages\LVGL-v8.3.11\src\extra\libs\rlottie;packages\LVGL-v8.3.11\src\extra\libs;packages\LVGL-v8.3.11\src\extra\themes\basic;packages\LVGL-v8.3.11\src\extra\others\gridnav;packages\LVGL-v8.3.11\src\draw\sw;packages\LVGL-v8.3.11\src\extra\libs\freetype;rt-thread\include;rt-thread\components\drivers\include;board;packages\LVGL-v8.3.11\src\draw\stm32_dma2d;build\libraries\SWM341_CSL\CMSIS\DeviceSupport;packages\LVGL-v8.3.11\src\extra\widgets\msgbox;packages\LVGL-v8.3.11\src\extra\widgets\calendar;packages\LVGL-v8.3.11\src\extra\libs\ffmpeg;packages\LVGL-v8.3.11\src\extra\widgets\imgbtn;packages\LVGL-v8.3.11\src;packages\LVGL-v8.3.11\src\extra\widgets\spinbox;packages\LVGL-v8.3.11\src\extra\widgets\win;packages\LVGL-v8.3.11\src\extra\widgets\list;packages\LVGL-v8.3.11\src\draw\swm341_dma2d;packages\LVGL-v8.3.11\src\extra\others\imgfont;packages\LVGL-v8.3.11\src\extra\libs\gif;rt-thread\components\libc\posix\io\eventfd;packages\gt9147-v1.1.0\inc;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\cortex-m33;packages\LVGL-v8.3.11\src\extra\others\monkey;packages\LVGL-v8.3.11\src\extra;packages\LVGL-v8.3.11\src\misc;packages\LVGL-v8.3.11\src\extra\libs\sjpg;packages\LVGL-v8.3.11\src\extra\widgets\colorwheel;packages\LVGL-v8.3.11\src\extra\themes;packages\LVGL-v8.3.11\src\extra\libs\fsdrv;packages\LVGL-v8.3.11\src\extra\libs\tiny_ttf;rt-thread\components\libc\posix\ipc;packages\LVGL-v8.3.11\src\extra\widgets\meter;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\themes\default;rt-thread\components\drivers\touch;rt-thread\components\libc\posix\io\poll;applications;packages\LVGL-v8.3.11\src\font;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\include;build\libraries\SWM341_CSL\CMSIS\CoreSupport;packages\LVGL-v8.3.11\src\extra\widgets\menu;packages\LVGL-v8.3.11\src\extra\widgets;packages\LVGL-v8.3.11\src\extra\widgets\animimg;packages\LVGL-v8.3.11\src\draw\nxp\vglite;rt-thread\components\drivers\phy;packages\LVGL-v8.3.11\src\extra\layouts\grid;packages\LVGL-v8.3.11\src\extra\widgets\spinner;packages\LVGL-v8.3.11\src\extra\widgets\span;packages\LVGL-v8.3.11\src\extra\others\ime;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v8.3.11\src\extra\themes\mono;packages\LVGL-v8.3.11\src\widgets;packages\LVGL-v8.3.11\src\extra\widgets\tabview;packages\LVGL-v8.3.11\src\hal;packages\LVGL-v8.3.11\src\extra\layouts;packages\LVGL-v8.3.11\src\core;packages\LVGL-v8.3.11\src\draw\sdl;packages\LVGL-v8.3.11\src\extra\libs\qrcode;packages\LVGL-v8.3.11\env_support\rt-thread;packages\LVGL-v8.3.11\src\extra\widgets\keyboard;rt-thread\components\finsh;packages\LVGL-v8.3.11\src\extra\widgets\led;middleware\lvgl_pm;packages\LVGL-v8.3.11\src\draw\nxp\pxp;packages\LVGL-v8.3.11\src\draw;rt-thread\libcpu\arm\common
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Board
    board/: board.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/touch/: dev_touch.c
  group Drivers
    build/libraries/SWM341_drivers/: drv_rgb_lcd.c drv_soft_i2c.c drv_gpio.c drv_sfc.c drv_uart.c drv_sdram.c
  group Finsh
    rt-thread/components/finsh/: cmd.c shell.c msh_parse.c msh.c
  group gt9147
    packages/gt9147-v1.1.0/src/: gt9147.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: kstdio.c kstring.c rt_vsnprintf_tiny.c kerrno.c rt_vsscanf.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    build/libraries/SWM341_CSL/SWM341_StdPeriph_Driver/: SWM341_sfc.c SWM341_lcd.c SWM341_sdram.c SWM341_crc.c SWM341_flash.c SWM341_sdio.c SWM341_wdt.c SWM341_jpeg.c SWM341_sleep.c SWM341_can.c SWM341_port.c SWM341_rtc.c SWM341_adc.c SWM341_usbh.c SWM341_gpio.c SWM341_qei.c SWM341_cordic.c SWM341_usbd.c SWM341_dma.c SWM341_timr.c SWM341_iofilt.c SWM341_spi.c SWM341_div.c SWM341_uart.c SWM341_pwm.c SWM341_dac.c SWM341_i2c.c SWM341_dma2d.c SWM341_exti.c
    build/libraries/SWM341_CSL/CMSIS/DeviceSupport/: system_SWM341.c
    build/libraries/SWM341_CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
  group LVGL
    packages/LVGL-v8.3.11/src/draw/sw/: lv_draw_sw_dither.c lv_draw_sw_layer.c lv_draw_sw.c lv_draw_sw_img.c lv_draw_sw_line.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw_letter.c lv_draw_sw_blend.c lv_draw_sw_polygon.c lv_draw_sw_arc.c lv_draw_sw_gradient.c
    packages/LVGL-v8.3.11/src/core/: lv_indev_scroll.c lv_obj_pos.c lv_obj.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_tree.c lv_indev.c lv_refr.c lv_obj_class.c lv_theme.c lv_disp.c lv_obj_style.c lv_group.c lv_event.c lv_obj_draw.c
    packages/LVGL-v8.3.11/src/draw/: lv_draw_label.c lv_draw_img.c lv_draw_mask.c lv_draw_rect.c lv_img_buf.c lv_draw_transform.c lv_draw_triangle.c lv_draw.c lv_draw_line.c lv_img_cache.c lv_draw_arc.c lv_img_decoder.c lv_draw_layer.c
    packages/LVGL-v8.3.11/src/misc/: lv_bidi.c lv_templ.c lv_txt_ap.c lv_async.c lv_utils.c lv_anim.c lv_area.c lv_color.c lv_tlsf.c lv_style_gen.c lv_txt.c lv_math.c lv_fs.c lv_style.c lv_log.c lv_timer.c lv_ll.c lv_printf.c lv_lru.c lv_gc.c lv_mem.c lv_anim_timeline.c
    packages/LVGL-v8.3.11/src/draw/sdl/: lv_draw_sdl_polygon.c lv_draw_sdl_composite.c lv_draw_sdl_mask.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_rect.c lv_draw_sdl_line.c lv_draw_sdl_stack_blur.c lv_draw_sdl.c lv_draw_sdl_utils.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_texture_cache.c
    packages/LVGL-v8.3.11/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.11/src/font/: lv_font_montserrat_32.c lv_font_montserrat_18.c lv_font_montserrat_22.c lv_font_fmt_txt.c lv_font_montserrat_36.c lv_font_montserrat_20.c lv_font_montserrat_48.c lv_font_montserrat_40.c lv_font_montserrat_8.c lv_font_loader.c lv_font_simsun_16_cjk.c lv_font_montserrat_12.c lv_font_montserrat_44.c lv_font_montserrat_12_subpx.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_34.c lv_font.c lv_font_montserrat_26.c lv_font_montserrat_42.c lv_font_montserrat_24.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font_montserrat_14.c lv_font_montserrat_38.c lv_font_montserrat_16.c lv_font_montserrat_28.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_46.c
    packages/LVGL-v8.3.11/src/widgets/: lv_objx_templ.c lv_arc.c lv_table.c lv_btnmatrix.c lv_img.c lv_label.c lv_btn.c lv_bar.c lv_line.c lv_textarea.c lv_slider.c lv_roller.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_switch.c
    packages/LVGL-v8.3.11/src/draw/nxp/vglite/: lv_draw_vglite_rect.c lv_draw_vglite_arc.c lv_vglite_buf.c lv_draw_vglite_blend.c lv_vglite_utils.c lv_draw_vglite.c lv_draw_vglite_line.c
    packages/LVGL-v8.3.11/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.11/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.11/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.11/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.11/src/draw/nxp/pxp/: lv_gpu_nxp_pxp_osa.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_draw_pxp.c
    packages/LVGL-v8.3.11/src/extra/libs/fsdrv/: lv_fs_win32.c lv_fs_posix.c lv_fs_littlefs.c lv_fs_fatfs.c lv_fs_stdio.c
    packages/LVGL-v8.3.11/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.11/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.11/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.11/src/extra/: lv_extra.c
    packages/LVGL-v8.3.11/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.11/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.11/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.11/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.11/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.11/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.11/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.11/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.11/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.11/src/hal/: lv_hal_indev.c lv_hal_tick.c lv_hal_disp.c
    packages/LVGL-v8.3.11/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.11/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.11/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.11/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.11/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.11/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.11/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.11/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.3.11/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v8.3.11/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.11/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.11/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.3.11/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.11/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.11/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.11/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.11/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.11/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.11/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.11/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.11/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.11/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.11/src/extra/others/imgfont/: lv_imgfont.c
  group LVGL-app
    lvgl_app/: page2.c page1.c lvgl_app.c
  group LVGL-pm
    middleware/lvgl_pm/: pm.c anima.c pm_utils.c
  group LVGL-port
    packages/LVGL-v8.3.11/env_support/rt-thread/: lv_port_disp.c lv_rt_thread_port.c lv_port_indev.c

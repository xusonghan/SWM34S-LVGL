# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\posix\io\eventfd; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\ipc; ..\libraries\SWM341_drivers; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\drivers\smp_call; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\libraries\SWM341_CSL\CMSIS\CoreSupport; ..\libraries\SWM341_CSL\SWM341_StdPeriph_Driver; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\libc\compilers\common\extension; applications; .; ..\..\..\libcpu\arm\cortex-m33; ..\libraries\SWM341_CSL\CMSIS\DeviceSupport; board; ..\..\..\components\drivers\phy; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; ..\..\..\components\finsh
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Board
    board/: board.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/SWM341_drivers/: drv_uart.c drv_gpio.c
  group Finsh
    ../../../components/finsh/: msh.c cmd.c msh_parse.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsnprintf_tiny.c kstring.c kstdio.c kerrno.c rt_vsscanf.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group Libraries
    ../libraries/SWM341_CSL/SWM341_StdPeriph_Driver/: SWM341_wdt.c SWM341_exti.c SWM341_gpio.c SWM341_div.c SWM341_sdio.c SWM341_port.c SWM341_flash.c SWM341_sdram.c SWM341_iofilt.c SWM341_uart.c SWM341_qei.c SWM341_can.c SWM341_sfc.c SWM341_dac.c SWM341_crc.c SWM341_spi.c SWM341_timr.c SWM341_jpeg.c SWM341_adc.c SWM341_pwm.c SWM341_cordic.c SWM341_usbd.c SWM341_dma2d.c SWM341_dma.c SWM341_usbh.c SWM341_sleep.c SWM341_lcd.c SWM341_rtc.c SWM341_i2c.c
    ../libraries/SWM341_CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM341.s
    ../libraries/SWM341_CSL/CMSIS/DeviceSupport/: system_SWM341.c

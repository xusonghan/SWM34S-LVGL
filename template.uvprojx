# Keil uVision project template.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.1.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
